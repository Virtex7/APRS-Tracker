# Repository Virtex7/APRS-Tracker

File README.md:

# APRS-Tracker
APRS-Sender in Leichtbauweise für Modellflieger oder Modellfahrzeuge

#3 Achtung:
Dieses Projekt verwendet das Repo "PhilippsKicadBauteile". Dieses muss auf gleicher Ebene wie das APRS-Tracker-Repository abgelegt sein, damit KiCAD es die Bauteile und Footprints finden kann.

## KiCad design Hardware/stm32 APRS Tracker.kicad_pcb

Parts:
BT101: CR2032
C1, C101, C106, C108: 22u; C_0805
C2, C4, C5, C6, C7, C102, C103, C104, C105, C107, C112: 100n; C_0603
C3: 10n; C_Disc_D3_P2.5
C8, C9: 47p; C_0603
C109: 3-12p
C110: 10-40p
C111: 10u; R_0805
D1: STPS340U; Diode-SMB_Standard
D2: LED; LED-0603
D3: 1n4148; Diode-MiniMELF_Standard
D4: 3,6V; Diode-MiniMELF_Standard
D101: grün_on_air; LED-0603
D102: orange_txprw_high; LED-0603
D103: rot_logging_on; LED-0603
D104: grün_gps_lock; LED-0603
DRA101: DRA818V; DRA8x8
IC1: STM32F103x; LQFP-64_10x10mm_Pitch0.5mm
L101, L105: 1x4mm
L102, L103, L104: 4x4mm
P1: USB_B; USB_Mini-B
P101, P102: CONN_01X04; Pin_Header_Straight_1x04
P103: CONN_01X01; Pin_Header_Straight_1x01
R1, R102, R104, R106, R108: 220; R_0603
R2, R5, R6, R7: 4,7k; R_0603
R3: R; R_0603
R4: 1M; Resistor_Horizontal_RM10mm
R8: 100k; R_0603
R9, R10: 22; R_0603
R11: 1,5k; R_0603
R101, R103, R107, R109, R110, R111, R113, R114, R115, R116: 1k; R_0603
R105: 10k; R_0603
R117: 390; R_0603
RP101: 3,3k; R_Array_Convex_4x0603
SW101: SW_TxPwr; Button_SMD_Schurter_LSG
U1: AP1117D33; SOT89-3_Housing
U2: SP0503BAHTG; SOT-143
U101: STM32_mmvisual_JTAG; con-amp-micromatch-MICROMATCH-10
Y101: 8 MHz; CSTCE_3,2x1,3
Y102: 32,768; C_1206

Connections:
+3V3: C5.1, C103.2, C104.1, C105.1, C106.1, C107.1, C108.1, D3.2 (A), DRA101.8 (Vcc), IC1.19 (V_DD4), IC1.32 (V_DD1), IC1.48 (V_DD2), IC1.64 (V_DD3), P101.1, P102.1, R7.1, R11.1, R103.2, R107.1, RP101.1, RP101.2, RP101.3, RP101.4, U1.2 (VO), U101.9 (Vcc); also elsewhere on the board
+5V: D1.2 (A), D2.2 (A), P1.1 (VCC), R5.1, U2.4 (D1)
+BATT: BT101.1, C101.1, C102.1, IC1.1 (V_BAT)
/320x240 LCD Module/CS: IC1.38 (SDIO7|I2S3|PC7); also elsewhere on the board
/320x240 LCD Module/D0: IC1.26 (ADC12_8|PB0); also elsewhere on the board
/320x240 LCD Module/D1: IC1.27 (ADC12_9|PB1); also elsewhere on the board
/320x240 LCD Module/D2: IC1.28 (BOOT1|PB2); also elsewhere on the board
/320x240 LCD Module/D3: IC1.55 (I2S3|SPI1/3|PB3); also elsewhere on the board
/320x240 LCD Module/D4: IC1.56 (SPI1/3|NJTRST|PB4); also elsewhere on the board
/320x240 LCD Module/D5: IC1.57 (I2S3|I2C1|SPI1/3|PB5); also elsewhere on the board
/320x240 LCD Module/D6: IC1.58 (UART1|I2C1|PB6); also elsewhere on the board
/320x240 LCD Module/D7: IC1.59 (UART1|I2C1|PB7); also elsewhere on the board
/320x240 LCD Module/RD: IC1.52 (SDIO3|UART3/4|PC11); also elsewhere on the board
/320x240 LCD Module/RS: IC1.51 (SDIO2|UART3/4|PC10); also elsewhere on the board
/320x240 LCD Module/Reset: IC1.7 (NRST), U101.1 (nReset); also elsewhere on the board
/320x240 LCD Module/Rst: IC1.41 (PA8|UART1); also elsewhere on the board
/320x240 LCD Module/SD_CS: RP101.5 (R4); also elsewhere on the board
/320x240 LCD Module/SD_MISO: IC1.39 (SDIO0|PC8), RP101.7 (R2); also elsewhere on the board
/320x240 LCD Module/SD_MOSI: IC1.54 (PD2|UART5|SDIO_CMD), RP101.6 (R3); also elsewhere on the board
/320x240 LCD Module/SD_ON: IC1.25 (ADC12_15|PC5); also elsewhere on the board
/320x240 LCD Module/SD_SCK: IC1.53 (SDIO_CK|UART3/5|PC12), RP101.8 (R1); also elsewhere on the board
/320x240 LCD Module/WR: IC1.40 (SDIO1|PC9); also elsewhere on the board
/DAC1: IC1.20 (PA4|SPI1|UART2|DA1|ADC12_4), R117.1
/GPS_RX: IC1.29 (UART3|I2C2|PB10), R111.2
/GPS_TX: IC1.30 (UART3|I2C2|PB11), R110.1
/HfPowerDown: DRA101.6 (PowerDown), IC1.9 (ADC123_11|PC1)
/I2C1_SCL: IC1.61 (CAN|SDIO4|I2C1|PB8), P101.3, R107.2
/I2C1_SDA: IC1.62 (CAN|SDIO5|I2C1|PB9), P101.2, R103.1
/LED_0: D104.2 (A), IC1.33 (UART3|I2X2|SPI2|PB12)
/LED_1: D101.2 (A), IC1.34 (UART3|I2C2|SPI2|PB13)
/LED_2: D102.2 (A), IC1.35 (UART3|SPI2|PB14)
/LED_3: D103.2 (A), IC1.36 (I2S2|SPI2|PB15)
/PTT: IC1.14 (PA0|WKUP|UART2|ADC123_0), R109.2
/SPI1_MISO: IC1.22 (PA6|SPI1|ADC12_6)
/SPI1_MOSI: IC1.23 (PA7|SPI1|ADC12_7)
/SPI1_SCK: IC1.21 (PA5|SPI1|DA2|ADC12_5)
/Squelch: DRA101.1 (SqelchOut), IC1.50 (PA15|SPI3/1|I2S3|JTDI)
/SwClk: IC1.49 (PA14|JTCK), U101.3 (TCK/SwClk)
/SwDio: IC1.46 (PA13|JTMS), U101.5 (TMS/SwdIo)
/TXPower: DRA101.7 (TXPwr_H/~L), IC1.8 (ADC123_10|PC0), R105.1
/Tast0: IC1.37 (SDIO6|I2S2|PC6), SW101.1
/U_3,3V: C7.1, IC1.24 (ADC12_14|PC4), R7.2, R8.1
/U_Akku: C4.1, IC1.10 (ADC123_12|PC2), R2.2, R3.1
/U_USB: C6.1, D4.1 (K), IC1.11 (ADC123_13|PC3), R5.2, R6.1
/analogIn: C111.2, IC1.15 (PA1|UART2|ADC123_1), R115.2, R116.1
/uart1rx: IC1.43 (PA10|UART1), R114.1
/uart1tx: IC1.42 (PA9|UART1), R113.2
/uart2rx: IC1.17 (PA3|UART2|ADC123_3), U101.10 (U1_RX)
/uart2tx: IC1.16 (PA2|UART2|ADC123_2), U101.8 (U1_TX)
Akku: R2.1; also elsewhere on the board
GNDA: C4.2, C6.2, C7.2, D4.2 (A), IC1.12 (V_SSA), R3.2, R6.2, R8.2; also elsewhere on the board
unnamed: C1.1, C2.2, D1.1 (K), D3.1 (K), U1.3 (VI)
unnamed: C3.1, P1.5 (shield), R4.2
unnamed: C8.1, IC1.44 (PA11|UART1|CAN|USBDM), R9.2
unnamed: C9.1, IC1.45 (PA12|UART1|CAN|USBDP), R10.1, R11.2
unnamed: C109.1, L101.2, L102.1
unnamed: C110.1, L102.2, L103.1
unnamed: C111.1, DRA101.3 (AF_Out)
unnamed: C112.1, DRA101.18 (Mic_In), R117.2
unnamed: D2.1 (K), R1.1
unnamed: D101.1 (K), R102.1
unnamed: D102.1 (K), R104.1
unnamed: D103.1 (K), R106.1
unnamed: D104.1 (K), R108.1
unnamed: DRA101.5 (PTT), R109.1
unnamed: DRA101.12 (Antenna), L101.1
unnamed: DRA101.16 (UartRx), R113.1
unnamed: DRA101.17 (UartTx), R114.2
unnamed: IC1.3 (OSC32_IN|PC14), Y102.1
unnamed: IC1.4 (OSC32_OUT|PC15), Y102.2
unnamed: IC1.5 (OSC_IN), Y101.1
unnamed: IC1.6 (OSC_OUT), Y101.3
unnamed: IC1.60 (BOOT0), R101.2
unnamed: L103.2, P103.1
unnamed: P1.2 (D-), R9.1, U2.2 (D2)
unnamed: P1.3 (D+), R10.2, U2.3 (D3)
unnamed: P102.2, R110.2
unnamed: P102.3, R111.1
VAA: IC1.13 (V_DDA), R115.1; also elsewhere on the board

Notes on the sheet:
Achtung! nur SWD-Programmierung, kein JTAG
Vin to 3,3V Wandler Iout maximal 1,5A
Saugkreis für 1. Oberwelle
Hier das GPS-Modul anschließen
Tiefpass für Sollsignal
Ausgang- Anpassung (Trafo)
Sinnvolle Verwendung der seriellen Schnittstellen: I2C1: TempSensor LM75 SPI1: SD-Karte UART1: 2m-Funkmodul UART2: Debug-Stecker UART3: GPS input 8 Bit Parallel: LCD
TPF 4,1kHz
LCD
V_ADC darf maximal 1,2V sein. R_ADC ist xx,xx k-Ohm
IMU modul hier anbringen

Parts:
C201, C203, C210, C213: 100n; C_0603
C202: 470p; C_0603
C204: 12n; C_0603
C205: 4,7n; C_0603
C206: 22u; C_0805
C207: 120p; C_0603
C208: 3,3n; C_0603
C209: 100p; C_0603
C211, C216: 1u; C_0805
C212: 3,3u; C_1812; Digikey-Nummer 445-3917-1-ND
C214: 680p; C_0603
C215: 2,2n; C_0603
C217: 22u; C_1210; Digikey-Nummer 490-1882-1-ND
D201: VC120630D650RP; C_1206
D202: 1N4148; Diode-MiniMELF_Standard
F201: 2,5A
L201: EMI Filter; R_0805
L202: 22uH; Choke_SMD_Wuerth-WE-PD-Typ-LS; Digikey-Nummer 732-1352-1-ND
P201: CONN_01X02; Pin_Header_Straight_1x02
Q201, Q202: CSD18532Q5B; SON5x6_FET_123; Digikey-Nummer 296-35628-1-ND
R201, R215, R216: 0*; R_0603
R202: 1; R_0603
R203: 7,15k; R_0603
R204: 2,67k; R_0603
R205: 169k; R_0603
R206: 1k; R_0603
R207: 267k; R_0603
R208: 10k; R_0603
R209: 243k; R_0603
R210: 49,9k; R_0603
R211: 3,32k; R_0603
R212: 8,2k; R_0603
R213: 0; R_0603
R214: 4,7; R_2010
U201: TPS40054; TSSOP-16-1EP_4.4x5mm_Pitch0.65mm

Connections:
+3V3: C208.2, C216.1, C217.1, L202.2, R202.2, R208.1; also elsewhere on the board
Akku: C209.1, C210.1, C212.1, D201.1 (K), F201.2, Q201.3 (D), R210.1, R211.1, U201.15 (Vin); also elsewhere on the board
GNDA: R216.2; also elsewhere on the board
unnamed: C202.2, D202.1 (K), R209.1
unnamed: C203.2, U201.3 (BP5)
unnamed: C204.2, U201.6 (SS/~SD)
unnamed: C205.1, R203.1
unnamed: C205.2, C207.2, U201.8 (COMP)
unnamed: C207.1, R203.2, R204.1, R207.2, R208.2, U201.7 (VFB)
unnamed: C208.1, R207.1
unnamed: C209.2, R211.2, U201.16 (ILim)
unnamed: C211.1, U201.11 (BP10)
unnamed: C213.1, R212.2
unnamed: C213.2, L202.1, Q201.1 (S), Q202.3 (D), R213.2, R214.1
unnamed: C214.1, D202.2 (A), Q202.2 (G), U201.10 (LDrv)
unnamed: C215.1, R214.2
unnamed 76: P201.1; also elsewhere on the board
unnamed: L201.2, R202.1
unnamed: Q201.2 (G), U201.13 (HDrv)
unnamed: R205.2, U201.2 (RT)
unnamed: R206.1, U201.4 (Sync)
unnamed: R209.2, R210.2, U201.1 (KFF)
unnamed: R212.1, U201.14 (Boost)
unnamed: R213.1, U201.12 (SW)
VAA: C201.1, C206.1, L201.1; also elsewhere on the board

Notes on the sheet:
Vin: 2s bis 6s 24V erlaubt!
Filter für Vaa
Anschluss von zwei Akkus sinnvoll, damit bei Ausfall die Schaltung weiter versorgt werden kann.

Parts:
C301: 100n; C_0603
P301, P302: CONN_01X06; Pin_Header_Straight_1x06
P303, P304: CONN_01X08; Pin_Header_Straight_1x08
Q301: BC807-40; SOT-23
R301: 1k; R_0603

Connections:
+3V3: P301.2, P301.6, Q301.2 (E); also elsewhere on the board
/320x240 LCD Module/CS: P302.4; also elsewhere on the board
/320x240 LCD Module/D0: P303.8; also elsewhere on the board
/320x240 LCD Module/D1: P303.7; also elsewhere on the board
/320x240 LCD Module/D2: P304.6; also elsewhere on the board
/320x240 LCD Module/D3: P304.5; also elsewhere on the board
/320x240 LCD Module/D4: P304.4; also elsewhere on the board
/320x240 LCD Module/D5: P304.3; also elsewhere on the board
/320x240 LCD Module/D6: P304.2; also elsewhere on the board
/320x240 LCD Module/D7: P304.1; also elsewhere on the board
/320x240 LCD Module/RD: P302.1; also elsewhere on the board
/320x240 LCD Module/RS: P302.3; also elsewhere on the board
/320x240 LCD Module/Reset: P301.1; also elsewhere on the board
/320x240 LCD Module/Rst: P302.5; also elsewhere on the board
/320x240 LCD Module/SD_CS: P303.6; also elsewhere on the board
/320x240 LCD Module/SD_MISO: P303.4; also elsewhere on the board
/320x240 LCD Module/SD_MOSI: P303.5; also elsewhere on the board
/320x240 LCD Module/SD_ON: R301.1; also elsewhere on the board
/320x240 LCD Module/SD_SCK: P303.3; also elsewhere on the board
/320x240 LCD Module/WR: P302.2; also elsewhere on the board
unnamed: C301.1, P301.3, Q301.3 (C)
unnamed: Q301.1 (B), R301.2

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
Board: 2 copper layers, 83.0 x 92.5 mm, 127 parts (0 on the bottom side), 103 nets.

Other parts of the board:
D5, D6: STPS340U; Diode-SMB_Standard
P2: CONN_01X02; Pin_Header_Straight_1x02
P3, P4, P5, P6: CONN_01X01; MountingHole_3mm

Their connections:
unnamed: D5.1, D6.1
unnamed: D5.2, P2.1
unnamed 76: D6.2; also elsewhere on the board

## Commit log

2015-07-02 gitignore zuerst.
2015-07-02 dateien dazugefügt - initial commit
2015-07-02 relativen Pfad für kicad libs versucht
2015-07-02 readme a weng geschrieben
2015-07-02 schaltplan weiter
2015-07-04 testprogramm für den STM32 geschrieben, das schon mal das LCD ansteuern kann.
2015-07-04 sdcard angefangen
2015-07-04 sdcard
2015-07-05 sdkarte weiter probiert - noch kein erfolg.
2015-07-06 andere sd card lib versuchen (openfat)
2015-07-10 es ist wohl ein größerer stm32 nötig. mit mehr pins.
2015-07-12 Relative Pfade für die Libs
2015-07-12 mcu wird immer größer, jetzt wohl F1
2015-07-12 OpenFat auf https url geändert
2015-07-12 Anpassen der Datenblätter
2015-07-12 Hinzufügen des STM32F103 (Entwurf)
2015-07-12 umbau auf massiv größeren STM fast abgeschlossen.
2015-07-12 neuer stm eingebunden und adcs angeschlossen
2015-07-13 Schaltplan momentan fertig - Netzliste angefangen.
2015-07-17 Platine angefangen - es wird auf jeden Fall eng
2015-07-24 Schaltwandler fast fertig
2015-07-26 Layout durchaus weiter, STM fast komplett angeschlossen
2015-07-26 platine fast fertig.
2015-07-27 Platine bis auf Sicherung fertig
2015-08-02 Anpassung des Siebdrucks, USB Buchse rausgeführt
